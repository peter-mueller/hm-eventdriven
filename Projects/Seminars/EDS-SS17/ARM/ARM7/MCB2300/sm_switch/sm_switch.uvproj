# Keil uVision project sm_switch.uvproj, settings and files
target sm_switch (ARM-ADS)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: sm_switch
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\..\..\..\CPU_Platforms\ARM\ARM7\MCB2300\include;..\..\..\..\..\..\..\Frameworks\Quantum\qpc_5.3.1\qpc\include;..\..\..\..\..\..\..\Frameworks\Quantum\qpc_5.3.1\qpc\ports\arm7\Keil;.\bsp
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group app
    ./app/: main.c
  group startup
    ../../../../../../../CPU_Platforms/ARM/ARM7/MCB2300/startup/: startup.s swi_interrup.s
  group drivers
    ../../../../../../../CPU_Platforms/ARM/ARM7/MCB2300/drivers/: Serial.c
  group bsp
    ./bsp/: bsp.c bsp.h
